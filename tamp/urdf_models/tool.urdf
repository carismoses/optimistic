Commit message: Adding more tool grasp options and starting contact actions

File: tamp/urdf_models/tool.urdf (robot description, URDF)
Before this commit: robot tool, 2 links, 1 joints
Joints:
- joint connect_handles: origin xyz=-0.185 0.085 0.0 rpy=0 0 0 -> xyz=-0.185 0.115 0.0 rpy=0 0 0
